# Keil uVision project IntCtrl_Driver.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IntCtrl_Driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Projects;..\..\Sprints_repo\Session_2\Common_Folders;..\Projects;..\..\Sprints_repo\Session_2\CPU_Driver
  asm include: ..\..\Sprints_repo\Session_2\Common_Folders;..\..\Sprints_repo\Session_2\CPU_Driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group IntCtrl
    ./: IntCtrl_Program.c IntCtrl_Lcfg.c
  group Main
    ./: main.c
  group CPU
    ./: CPU_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
